# Keil uVision project SD.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC12C5A16S2 Series
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: SD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c myfun.c sd.c uart.c
    ./znFAT/: deviceio.c znFAT.c
